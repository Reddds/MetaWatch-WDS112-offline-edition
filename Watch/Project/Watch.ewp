# IAR project Watch.ewp, settings and files
configuration Devboard (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 280
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DIGITAL; HW_DEVBOARD_V2
  ICC430.PreInclude: ..\Application\PreInclude.h
  ICC430.newCCIncludePaths: ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\MSP430F5438; ..\..\OSAL; ..\..\Patch; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application; ..\..\Stack\Api
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: LinkerConfiguration.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -C ..\..\Stack\Api\IAR\Stack2.a; -C ..\..\Stack\Api\IAR\Stack.r43
configuration Digital (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; DIARY
  ICC430.CCDiagSuppress: Pa050,Pa082
  ICC430.newCCIncludePaths: ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\MSP430F5438; ..\..\OSAL; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application; ..\..\Stack\Api
configuration Analog Devboard (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ANALOG; HW_DEVBOARD_V2
  ICC430.newCCIncludePaths: as above
configuration Analog (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ANALOG; WATCH
  ICC430.newCCIncludePaths: as above
configuration Digital BLE (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; USE_LOW_ENERGY
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: as above
  XLINK.XExtraOptions: -C ..\..\Stack\Api\IAR\Stack2-BLE.a; -C ..\..\Stack\Api\IAR\Stack-BLE.r43; -C ..\..\Stack\Api\IAR\libSS1BTGAT.a
  group Application
    ../Application/: Accelerometer.c Adc.c Background.c Background.h BufferPool.c Buttons.c Calendar.c Calendar.h DebugUart.c Display.c Display.h Fonts.c Fonts.h Icons.c Icons.h InterruptVectors.c LcdDisplay.c LcdDisplay.h LcdDriver.c main.c MessageQueues.c Messages.h OneSecondTimers.c PreInclude.h SerialRam.c SerialRam.h Statistics.c Utilities.c Utilities.h Vibration.c
  group FreeRTOS
    ../../FreeRTOS/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/include
    ../../FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h TaskTCB.h
  group FreeRTOS/portable/MemMang
    ../../FreeRTOS/portable/MemMang/: heap_2.c
  group FreeRTOS/portable/MSP430F5438A
    ../../FreeRTOS/portable/MSP430F5438/: FreeRTOSConfig.h Lowinit.c port.c portext_s43.asm portext_s43_ccs.asm portmacro.h
  group Hardware
    ../Hardware/: hal_accelerometer.c hal_analog_display.c hal_analog_v2_defs.h hal_battery.c hal_board_type.h hal_calibration.c hal_clock_control.c hal_devboard_v2_defs.h hal_digital_v2_defs.h hal_lpm.c hal_miscellaneous.c hal_oled.c hal_rtc.c hal_rtos_timer.c hal_software_fll.c hal_vibe.c OledDriver.c
    ../Application/: OledFonts.c
  group Hardware/F5xx_F6xx_Core_Lib
    ../Hardware/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group OSAL
    ../../OSAL/: MSP430FlashUtil.c NvIds.h OSAL_Nv.c
  group Patch
    ../../Patch/: Patch_PAN1315.h Patch_PAN1316.h PatchSelection.c PatchSelection.h
